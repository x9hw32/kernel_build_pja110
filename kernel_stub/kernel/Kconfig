## kernel_stub/kernel/Kconfig
```kconfig
menu "KernelSU Stub"
config KSU
	bool "KernelSU function support (Stub)"
	default n
endmenu
```
